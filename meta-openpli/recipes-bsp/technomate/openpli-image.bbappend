IMAGE_INSTALL += "directfb"