IMAGE_INSTALL += "enigma2-plugin-softcams-newcs"
IMAGE_INSTALL += "enigma2-plugin-softcams-newcs-config"
IMAGE_INSTALL += "enigma2-plugin-softcams-mgcamd"
